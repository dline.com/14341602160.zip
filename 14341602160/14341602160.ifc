Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-11-08T11:10:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 08 11:10:14 2017 * Host: DESKTOP-FI6EGIK * Database: C:\Users\CERTIF~1\AppData\Local\Temp\{F73440A0-607B-41F8-B66A-2ADCF6BFD3F8}\ifc * Database version: 5507 * Database creation date: Wed Nov 08 11:10:13 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 08 11:10:13 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 08 11:10:13 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: 8mm Head
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDoor: dline_Hardware_ThumbTurn_SnapOnRose, 14341602160b:dline_Hardware_ThumbTurn_SnapOnRose:194055
In: Level 1
Type - ParameterTakesPrecedence: no; Sizeable: no
Type - Analytical Properties - Analytic Construction: <None>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Data - ClassificationGradesMinimumCategoryOfUse: n/a; ClassificationGradesMinimumCorrosionResistance: n/a; ClassificationGradesMinimumDoorMass: n/a; ClassificationGradesMinimumDurability: n/a; ClassificationGradesMinimumFireResistance: n/a; ClassificationGradesMinimumSafety: n/a; ClassificationGradesMinimumSecurity: n/a; ClassificationGradesMinimumTypeOfOperation: n/a; RoseType: Snap on
Type - Dimensions - DoorLeafThickness: 40 mm; RoseDiameter: 50 mm; RoseHeight: 4.01092 mm
Type - General - Author: Gytautas Balevičius; BIMObjectName: dline_Hardware_ThumbTurn; DesignCountry: Denmark; ManufacturerName: d line; ManufacturerURL: www.dline.com; MasterFormat2014Code: 08 71 00; MasterFormat2014Description: Door hardware; NBSCertification: n/a; NBSDescription: Escutcheons; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-25-38/325; NBSTypeID: n/a; OmniclassCode: 22-08 71 00; OmniclassDescription: Door Hardware; ProductFamily: Hardware; ProductGroup: Thumb turns; ProductInformation: http://dline.com/product/knud-holscher-collection-thumb-turn/?attribute_pa_material=satin-stainless-steel-aisi-316&attribute_pa_item=snap-on-cover-cc-30-assaboda#; ProductionCountry: Lithuania; ProductSKU: 14341602160; Revision: n/a; Uniclass2015Code: Pr_30_36_33_27; Uniclass2015Title: Escutcheons; Uniclass2015Version: Products 1.5; UNSPSCCode: 31162801; Version: 1; Weight Net (kg): 0
Type - Identity Data - Description: Thumb turn in AISI 316 stainless steel, on snap on rose.; Manufacturer: info@dline.com; Type Mark: 22; Type Name: dline_Hardware_ThumbTurn_SnapOnRose
Type - Materials and Finishes - MainMaterial: AISI 316
Type - Other - AccessibilityPerformance: n/a; AssetType: fixed; Category: n/a; CodePerformance: n/a; Color: n/a; Constituents: Thumb turn; DurationUnit: year; ExpectedLife: 20 years; Family Name: 14341602160b; Features: n/a; Finish: Satin; Grade: n/a; Material: AISI 316; ModelNumber: n/a; ModelReference: n/a; Name: ThumbTurn; ReplacementCost: n/a; Shape: n/a; Size: 50 x 30 x 22 mm; SustainabilityPerformance: n/a; WarrantyDescription: 20 years (non-mechanical/-electronic parts) excluding labor; WarrantyDurationLabor: n/a; WarrantyDurationParts: 20; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: claim@dline.com
OverallHeight: 65.5109 mm; OverallWidth: 50 mm
Pset_DoorCommon - Reference: n/a; IsExternal: no; FireRating: n/a; AcousticRating: n/a; SecurityRating: n/a; HandicapAccessible: no; FireExit: no; SelfClosing: no; SmokeStop: no; GlazingAreaFraction: 0
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@dline.com
Constraints - Elevation: 1219.2 mm; Host: <not associated>; Level: Level: Level 1
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; BarCode: n/a; Category: Doors; Family: 14341602160b: dline_Hardware_ThumbTurn_SnapOnRose; Family and Type: 14341602160b: dline_Hardware_ThumbTurn_SnapOnRose; InstallationDate: 1900-12-31T23:59:59; Schedule Level: Level: Level 1; SerialNumber: n/a; TagNumber: n/a; Type: 14341602160b: dline_Hardware_ThumbTurn_SnapOnRose; Type Id: 14341602160b: dline_Hardware_ThumbTurn_SnapOnRose; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction
